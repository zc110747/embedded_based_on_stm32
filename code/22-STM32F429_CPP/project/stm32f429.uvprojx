# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (6140000::V6.14::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c include: ..\..\00-STM32F4xx_HAL_Driver\Inc;..\..\00-STM32F4xx_HAL_Driver\Inc\Legacy;..\..\00-Usr_Library\logger;..\..\00-Drivers;..\application;..\driver;..\..\00-Extend_Library\dsp_lib\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../00-Extend_Library/: system_stm32f4xx.c
    ./: startup_stm32f429xx.s
  group stm32f4xx_hal
    ../../00-STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group application
    ../application/: main.cpp stm32f4xx_it.c interrupt.cpp
  group include
    ../application/: stm32f4xx_it.h main.h stm32f4xx_hal_conf.h
  group logger
    ../../00-Usr_Library/logger/: logger.c
  group hw_lib
    ../driver/: ap3216.hpp i2c.hpp gpio.hpp dac.hpp
