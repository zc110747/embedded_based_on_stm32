# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429-start
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\00-STM32F4xx_HAL_Driver\Inc;..\..\00-STM32F4xx_HAL_Driver\Inc\Legacy;..\..\00-Extend_Library\segger_rtt\Config;..\..\00-Extend_Library\segger_rtt\RTT;..\..\00-Usr_Library\logger;..\..\00-Extend_Library\dsp_lib\Include;..\..\00-Drivers;..\application;..\..\00-Extend_Library\FreeRTOS\Source\include;..\..\00-Extend_Library\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\00-Extend_Library\FreeRTOS\Source\CMSIS_RTOS_V2;..\application\App;..\application\Target;..\..\00-Extend_Library\LwIP\src\include;..\..\00-Extend_Library\LwIP\system;..\..\00-Extend_Library\paho.mqtt\src;..\..\00-Extend_Library\paho.mqtt\src\FreeRTOS;..\..\00-Extend_Library\modbus\include;..\..\00-Extend_Library\modbus\ascii;..\..\00-Extend_Library\modbus\rtu;..\port;..\..\00-Extend_Library\modbus\tcp;..\..\00-Extend_Library\modbus\master;..\..\00-DriversChip
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../00-Extend_Library/: system_stm32f4xx.c
    ./: startup_stm32f429xx.s
  group stm32f4xx_hal
    ../../00-STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_eth.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group application
    ../application/: main.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c
    ../application/App/: logger_client.c mqtt_app.c
  group includes
    ../application/: includes.h global_def.h stm32f4xx_hal_conf.h FreeRTOSConfig.h
    ../../00-Drivers/: drv_global.h
  group thirdparts/segger_rtt
    ../../00-Extend_Library/segger_rtt/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group driver
    ../../00-Drivers/: drv_gpio.c drv_target.c drv_i2c.c drv_soft_i2c.c
    ../../00-DriversChip/: drv_i2c_pcf8574.c
  group usr_library
    ../../00-Usr_Library/logger/: logger.c
  group extern/FreeRTOS
    ../../00-Extend_Library/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../00-Extend_Library/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../00-Extend_Library/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../00-Extend_Library/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group extern/LwIP
    ../../00-Extend_Library/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../00-Extend_Library/LwIP/src/apps/mqtt/: mqtt.c
    ../../00-Extend_Library/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../00-Extend_Library/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../00-Extend_Library/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../00-Extend_Library/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../../00-Extend_Library/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group extern/LwIP/APP
    ../../00-Extend_Library/LwIP/system/OS/: sys_arch.c
    ../application/App/: lwip.c
    ../application/Target/: ethernetif.c lan8742.c
  group extern/mqtt
    ../../00-Extend_Library/paho.mqtt/: stdoutsub.c
    ../../00-Extend_Library/paho.mqtt/src/: MQTTClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../00-Extend_Library/paho.mqtt/src/FreeRTOS/: MQTTFreeRTOS.c
  group extern/modbus
    ../../00-Extend_Library/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../00-Extend_Library/modbus/ascii/: mbascii.c
    ../../00-Extend_Library/modbus/rtu/: mbcrc.c mbrtu.c
  group extern/modbus/slave
    ../../00-Extend_Library/modbus/: mb.c
    ../../00-Extend_Library/modbus/tcp/: mbtcp.c
    ../port/: portevent.c porttimer.c mbport.c portserial.c porttcp.c
    ../application/App/: mb_slave_example.c
  group extern/modbus/master
    ../port/: portserial_m.c porttimer_m.c portevent_m.c
    ../../00-Extend_Library/modbus/master/: mb_m.c mb_m.h mbfuncholding_m.c mbrtu_m.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncinput_m.c
    ../application/App/: mb_master_example.c mb_master_app_m.c
