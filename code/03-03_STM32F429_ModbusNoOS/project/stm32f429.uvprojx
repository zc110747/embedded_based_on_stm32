# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429-start
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\00-Extend_Library\dsp_lib\Include;..\..\00-STM32F4xx_HAL_Driver\Inc;..\application;..\..\00-Extend_Library\segger_rtt\Config;..\..\00-Extend_Library\segger_rtt\RTT;..\..\00-Drivers;..\..\00-Usr_Library\logger;..\port;..\..\00-Extend_Library\modbus\include;..\..\00-Extend_Library\modbus\rtu;..\..\00-Extend_Library\modbus\ascii;..\..\00-Extend_Library\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../00-Extend_Library/: system_stm32f4xx.c
    ./: startup_stm32f429xx.s
  group stm32f4xx_hal
    ../../00-STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group application
    ../application/: main.c stm32f4xx_it.c
  group includes
    ../application/: includes.h global_def.h stm32f4xx_hal_conf.h
    ../../00-Drivers/: drv_global.h drv_usart.h drv_gpio.h
  group thirdparts/segger_rtt
    ../../00-Extend_Library/segger_rtt/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group driver
    ../../00-Drivers/: drv_gpio.c drv_usart.c drv_target.c
  group usr_library
    ../../00-Usr_Library/logger/: logger.h logger.c
  group modbus/app
    ../../00-Extend_Library/modbus/: mb.c
    ../../00-Extend_Library/modbus/functions/: mbutils.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c
    ../../00-Extend_Library/modbus/rtu/: mbrtu.c mbcrc.c
    ../../00-Extend_Library/modbus/ascii/: mbascii.c
    ../../00-Extend_Library/modbus/tcp/: mbtcp.c
  group modbus/port
    ../port/: port.c portevent.c portserial.c porttimer.c porttcp.c
