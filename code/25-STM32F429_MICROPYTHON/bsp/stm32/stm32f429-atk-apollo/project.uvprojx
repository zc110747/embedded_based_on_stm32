# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F429xx, __RTTHREAD__, RT_USING_LIBC, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\libraries\HAL_Drivers\drivers;packages\micropython-v1.13.0\port\modules;packages\micropython-v1.13.0;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;packages\micropython-v1.13.0\port;..\..\..\components\drivers\include;applications;..\..\..\components\drivers\include;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\lwip\lwip-2.0.3\src\include\posix;..\..\..\components\libc\compilers\common\include;.;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\net\lwip\port;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\micropython-v1.13.0\port\modules\machine;..\..\..\components\drivers\include;board\ports;..\libraries\HAL_Drivers\drivers\config;board;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_soft_i2c.c drv_spi.c drv_tim.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c shell.c msh.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group MicroPython
    packages/micropython-v1.13.0/py/: mpstate.c frozenmod.c objproperty.c persistentcode.c stackctrl.c modcollections.c modarray.c objslice.c builtinevex.c modio.c objcell.c parsenum.c vm.c emitinlinextensa.c mpz.c emitnx64.c pystack.c builtinhelp.c asmbase.c modstruct.c gc.c binary.c mpprint.c nlrthumb.c objgenerator.c modbuiltins.c stream.c asmthumb.c modmath.c nlrpowerpc.c objint.c emitnxtensawin.c pairheap.c objsingleton.c argcheck.c obj.c objtuple.c scheduler.c compile.c asmx64.c nlrsetjmp.c objdeque.c nativeglue.c nlrx86.c malloc.c objlist.c objobject.c modsys.c objarray.c objint_longlong.c profile.c objmodule.c emitbc.c objbool.c objfloat.c objrange.c parse.c unicode.c nlr.c objexcept.c scope.c emitnarm.c asmx86.c moduerrno.c objcomplex.c lexer.c runtime.c repl.c modgc.c objclosure.c emitnxtensa.c objstr.c qstr.c builtinimport.c asmxtensa.c modmicropython.c objreversed.c objboundmeth.c modcmath.c objstringio.c ringbuf.c objdict.c objmap.c objpolyiter.c emitnx86.c objstrunicode.c sequence.c emitcommon.c objfilter.c objint_mpz.c showbc.c warning.c emitnative.c objnone.c smallint.c objnamedtuple.c objgetitemiter.c objset.c objzip.c vstr.c emitglue.c bc.c nlrxtensa.c objenumerate.c reader.c emitnthumb.c modthread.c nlrx64.c objfun.c formatfloat.c parsenumbase.c runtime_utils.c emitinlinethumb.c objattrtuple.c map.c objtype.c opmethods.c asmarm.c
    packages/micropython-v1.13.0/extmod/: modutimeq.c moduhashlib.c machine_signal.c modujson.c vfs_fat_diskio.c moduzlib.c moduselect.c vfs_fat_file.c modure.c vfs_posix_file.c machine_i2c.c utime_mphal.c moduwebsocket.c modwebsocket.c vfs_fat.c machine_pulse.c machine_spi.c modubinascii.c vfs_posix.c modbtree.c vfs_reader.c moducryptolib.c machine_mem.c vfs.c modussl_axtls.c modussl_mbedtls.c modframebuf.c modurandom.c virtpin.c machine_pinbase.c modwebrepl.c moductypes.c moduheapq.c uos_dupterm.c modonewire.c
    packages/micropython-v1.13.0/port/modules/: modfile.c modffi.c modusocket.c moduos_file.c modutime.c modnetwork.c modrtthread.c modutils.c modnetwork_wlan.c moduos.c modpyb.c
    packages/micropython-v1.13.0/port/modules/machine/: machine_uart.c machine_adc.c machine_rtc.c machine_wdt.c modmachine.c machine_lcd.c machine_hw_i2c.c machine_pwm.c machine_timer.c machine_pin.c machine_hw_spi.c
    packages/micropython-v1.13.0/port/: frozen_mpy.c mphalport.c gccollect.c mpthreadport.c mpgetcharport.c mpputsnport.c mpy_main.c
    packages/micropython-v1.13.0/lib/utils/: interrupt_char.c sys_stdio_mphal.c pyexec.c mpirq.c printf.c stdout_helpers.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/drivers/bus/: softspi.c softqspi.c
    packages/micropython-v1.13.0/port/native/: easyflash_module.c native_module.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
