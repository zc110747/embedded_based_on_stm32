# Keil uVision project STM32F429.uvprojx, settings and files
target display_alarm_clock (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\application;..\driver;..\..\..\00-STM32F4xx_HAL_Driver\Inc;..\..\..\00-Extend_Library\dsp_lib\Include;..\components\logger
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f429xx.s system_stm32f4xx.c
  group stm32f4xx_hal
    ../../../00-STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c
  group application
    ../application/: main.c
  group driver
    ../driver/: drv_gpio.c drv_rtc.c drv_sdram.c drv_target.c
  group components
    ../components/logger/: logger.c
  group includes
    ../driver/: drv_global.h drv_gpio.h drv_rtc.h drv_sdram.h
    ../application/: global_def.h includes.h stm32f4xx_it.h stm32f4xx_hal_conf.h
