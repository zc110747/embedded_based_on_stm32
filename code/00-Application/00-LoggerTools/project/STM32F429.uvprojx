# Keil uVision project STM32F429.uvprojx, settings and files
target logger_tools (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\application;..\driver;..\..\..\00-STM32F4xx_HAL_Driver\Inc;..\..\..\00-Extend_Library\dsp_lib\Include;..\components\logger;..\components\;..\..\..\00-Extend_Library\segger_rtt\RTT;..\..\..\00-Extend_Library\segger_rtt\Config;..\..\..\00-Extend_Library\ff15
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f429xx.s system_stm32f4xx.c
  group stm32f4xx_hal
    ../../../00-STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group application
    ../application/: main.c stm32f4xx_it.c log_extend.c
  group driver
    ../driver/: drv_target.c drv_logger_uart.c drv_sdio.c drv_logger_sdcard.c
  group components
    ../components/logger/: logger.c logger_interface.c
  group includes
    ../driver/: drv_global.h
    ../application/: global_def.h includes.h stm32f4xx_it.h stm32f4xx_hal_conf.h
    ../components/logger/: circular_buffer.h logger.h logger_interface.h
  group thirdparts/segger
    ../../../00-Extend_Library/segger_rtt/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group thirdparts/fatfs
    ../../../00-Extend_Library/ff15/: disk_interface.c diskio.c ff.c ffsystem.c ffunicode.c
